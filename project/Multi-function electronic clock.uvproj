# Keil uVision project Multi-function electronic clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Multi-function electronic clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\source
  group SourceFiles
    ../source/: STARTUP.A51 main.c Lcd1602.c LedBuzzer.c keyboard.c DS1302.c DS18B20.c Infrared.c Time.c
  group IncludeFiles
    ../source/: main.h config.h Lcd1602.h LedBuzzer.h keyboard.h DS1302.h DS18B20.h Infrared.h Time.h
